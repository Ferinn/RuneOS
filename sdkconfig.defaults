## sdkconfig.defaults
```kconfig
CONFIG_LV_BUILD_EXAMPLES=n
CONFIG_LV_BUILD_DEMOS=n
CONFIG_ESP_DEFAULT_CPU_FREQ_MHZ_360=y
CONFIG_BSP_I2C_FAST_MODE=y
```
